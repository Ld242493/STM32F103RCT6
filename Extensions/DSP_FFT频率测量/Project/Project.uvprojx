# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,ARM_MATH_CM3
  c include: ..\Core\CMSIS;..\Core\STM32F10x_StdPeriph_Driver\inc;..\DSP\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../Core/CMSIS/: system_stm32f10x.c startup_stm32f10x_hd.s
  group FWLIB
    ../Core/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group DEVICE
    ../User/LED/: led.c
    ../User/KEY/: key.c
    ../User/OLED/: OLED.c OLED_Data.c
    ../User/ADC/: adc.c
    ../User/PWM/: pwm.c
  group USER
    ../User/: main.c stm32f10x_it.c Systick.c usart.c
    ../DSP/: arm_cortexM3l_math.lib
software components: CMSIS:CORE 5.4.0
